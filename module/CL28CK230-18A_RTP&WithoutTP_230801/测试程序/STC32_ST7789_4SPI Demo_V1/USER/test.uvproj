# Keil uVision project test.uvproj, settings and files
target CL-TFT (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: test +hex
  group USER
    ./: main.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/LCD/: LCD.c
    ../HARDWARE/TEST/: test code.c
    ../HARDWARE/TOUCH/: touch.c ctiic.c ctp.c
    ../HARDWARE/W25QX/: w25qx.c
